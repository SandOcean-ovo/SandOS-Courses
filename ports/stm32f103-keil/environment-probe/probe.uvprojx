# Keil uVision project probe.uvprojx, settings and files
target EnvironmentProbe (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(8000000) ELITTLE
  output: probe
  c flags: Optim=1 uC99=1
  memory RVCT4: ROM 0x20000000 size 0x8000
  memory RVCT9: RAM 0x20008000 size 0x8000
  scatter file: .\probe.sct
  link misc: --entry Reset_Handler
  group Probe
    ./: startup.s probe.c
